<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>SDCCH</value></param>
<param><key>value</key><value>6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>PCH</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>BCCH</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>CHANNEL_UNKNOWN</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>CCCH</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>RACH</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>AGCH</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2000000.052982</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>fc</value></param>
<param><key>label</key><value>center_frequency</value></param>
<param><key>value</key><value>939.4e6</value></param>
<param><key>start</key><value>925e6</value></param>
<param><key>stop</key><value>960e6</value></param>
<param><key>step</key><value>2e5</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>min_len</key><value>100</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>g</value></param>
<param><key>label</key><value>gain</value></param>
<param><key>value</key><value>43</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>50</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>widget</key><value>counter</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>min_len</key><value>100</value></param>
</block>
<block>
<key>gsm_receiver</key>
<param><key>id</key><value>gsm_receiver_0</value></param>
<param><key>osr</key><value>4</value></param>
</block>
<block>
<key>gsm_message_printer</key>
<param><key>id</key><value>gsm_message_printer_1</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>port</key><value>4729</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
</block>
<block>
<key>gsm_control_channels_decoder</key>
<param><key>id</key><value>gsm_control_channels_decoder_0</value></param>
</block>
<block>
<key>gsm_universal_ctrl_chans_demapper</key>
<param><key>id</key><value>gsm_universal_ctrl_chans_demapper_0</value></param>
<param><key>starts_fn_mod51</key><value>[2,6,12,16,22,26,32,36,42,46]</value></param>
<param><key>channel_types</key><value>[BCCH,CCCH,CCCH,CCCH,CCCH,CCCH,CCCH,CCCH,CCCH,CCCH]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ppm_param</value></param>
<param><key>label</key><value>ppm</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>short_id</key><value>p</value></param>
</block>
<block>
<key>gsm_clock_offset_control</key>
<param><key>id</key><value>gsm_clock_offset_control_0</value></param>
<param><key>fc</key><value>fc</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ppm</value></param>
<param><key>label</key><value>clock_correction [ppm]</value></param>
<param><key>value</key><value>ppm_param</value></param>
<param><key>start</key><value>-150</value></param>
<param><key>stop</key><value>150</value></param>
<param><key>step</key><value>1</value></param>
<param><key>widget</key><value>counter</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>min_len</key><value>100</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>usrp_samp</value></param>
<param><key>label</key><value>Sampling </value></param>
<param><key>value</key><value>12.5e6</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>25e6</value></param>
<param><key>step</key><value>1</value></param>
<param><key>widget</key><value>slider</value></param>
<param><key>orient</key><value>Qt.Vertical</value></param>
<param><key>gui_hint</key><value>0,64,1,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Frequency</value></param>
<param><key>label</key><value>Center Frequency</value></param>
<param><key>value</key><value>947e6</value></param>
<param><key>start</key><value>400e6</value></param>
<param><key>stop</key><value>4e9</value></param>
<param><key>step</key><value>100000</value></param>
<param><key>widget</key><value>slider</value></param>
<param><key>orient</key><value>Qt.Vertical</value></param>
<param><key>gui_hint</key><value>0,62,1,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>usrp_gn</value></param>
<param><key>label</key><value>Gain RX</value></param>
<param><key>value</key><value>15</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>50</value></param>
<param><key>step</key><value>1</value></param>
<param><key>widget</key><value>slider</value></param>
<param><key>orient</key><value>Qt.Vertical</value></param>
<param><key>gui_hint</key><value>0,63,1,1</value></param>
</block>
<block>
<key>gsm_input</key>
<param><key>id</key><value>gsm_input_0</value></param>
<param><key>ppm</key><value>0</value></param>
<param><key>osr</key><value>4</value></param>
<param><key>samp_rate_in</key><value>samp_rate</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>BandWidth</value></param>
<param><key>label</key><value>BandWidth</value></param>
<param><key>value</key><value>250000</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>1e6</value></param>
<param><key>step</key><value>100</value></param>
<param><key>widget</key><value>slider</value></param>
<param><key>orient</key><value>Qt.Vertical</value></param>
<param><key>gui_hint</key><value>0,61,1,1</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>airprobe_bladerf</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>fc</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_1</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value>bladerf=0,fpga=/home/junaid/Downloads/hostedx115.rbf</value></param>
<param><key>sync</key><value></value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>fc</value></param>
<param><key>corr0</key><value>ppm</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>gain0</key><value>g</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>250e3</value></param>
</block>
<connection><source_block_id>gsm_clock_offset_control_0</source_block_id><sink_block_id>gsm_input_0</sink_block_id><source_key>ppm</source_key><sink_key>ppm_in</sink_key></connection>
<connection><source_block_id>gsm_input_0</source_block_id><sink_block_id>gsm_receiver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_universal_ctrl_chans_demapper_0</sink_block_id><source_key>C0</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0</source_block_id><sink_block_id>gsm_message_printer_1</sink_block_id><source_key>msgs</source_key><sink_key>msgs</sink_key></connection>
<connection><source_block_id>gsm_control_channels_decoder_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>msgs</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gsm_universal_ctrl_chans_demapper_0</source_block_id><sink_block_id>gsm_control_channels_decoder_0</sink_block_id><source_key>bursts</source_key><sink_key>bursts</sink_key></connection>
<connection><source_block_id>gsm_receiver_0</source_block_id><sink_block_id>gsm_clock_offset_control_0</sink_block_id><source_key>measurements</source_key><sink_key>measurements</sink_key></connection>
<connection><source_block_id>osmosdr_source_1</source_block_id><sink_block_id>gsm_input_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
